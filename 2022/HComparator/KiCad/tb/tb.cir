.title KiCad schematic
.include "/home/ryos/Project/MakeLSI/MakeLSI/2022/HComparator/HComparator/tb/16PTS/mos_PTS06.lib"
V1 /Sheet632C252D/VDD 0 dc 5
V2 /Sheet632C252D/VP 0 dc 2.25
V3 /Sheet632C252D/VM 0 pwl(0 0 1000n 5 2500n 0)
M1 Net-_M1-Pad1_ Net-_M1-Pad1_ /Sheet632C252D/VDD /Sheet632C252D/VDD PMOS_OR1 l=1u w=2u
M4 Net-_M3-Pad1_ Net-_M3-Pad1_ /Sheet632C252D/VDD /Sheet632C252D/VDD PMOS_OR1 l=1u w=2u
M7 Net-_M6-Pad1_ /Sheet632C252D/VP Net-_M3-Pad3_ 0 NMOS_OR1 l=1u w=2u
M5 Net-_M3-Pad3_ Net-_M1-Pad1_ 0 0 NMOS_OR1 l=1u w=2u
M8 Net-_M11-Pad1_ Net-_M3-Pad1_ /Sheet632C252D/VDD /Sheet632C252D/VDD PMOS_OR1 l=1u w=2u
M9 Net-_M11-Pad1_ Net-_M11-Pad1_ Net-_M10-Pad1_ 0 NMOS_OR1 l=1u w=2u
M2 Net-_M1-Pad1_ Net-_M1-Pad1_ 0 0 NMOS_OR1 l=1u w=2u
M3 Net-_M3-Pad1_ /Sheet632C252D/VM Net-_M3-Pad3_ 0 NMOS_OR1 l=1u w=2u
M6 Net-_M6-Pad1_ Net-_M12-Pad2_ /Sheet632C252D/VDD /Sheet632C252D/VDD PMOS_OR1 l=1u w=2u
M12 Net-_M11-Pad2_ Net-_M12-Pad2_ /Sheet632C252D/VDD /Sheet632C252D/VDD PMOS_OR1 l=1u w=2u
M11 Net-_M11-Pad1_ Net-_M11-Pad2_ Net-_M10-Pad1_ 0 NMOS_OR1 l=1u w=2u
M10 Net-_M10-Pad1_ Net-_M10-Pad1_ 0 0 NMOS_OR1 l=1u w=2u
M13 Net-_M11-Pad2_ Net-_M11-Pad1_ Net-_M10-Pad1_ 0 NMOS_OR1 l=1u w=2u
M14 Net-_M11-Pad2_ Net-_M11-Pad2_ Net-_M10-Pad1_ 0 NMOS_OR1 l=1u w=2u
M16 Net-_M15-Pad1_ Net-_M11-Pad2_ Net-_M16-Pad3_ 0 NMOS_OR1 l=1u w=2u
M15 Net-_M15-Pad1_ Net-_M11-Pad2_ Net-_M15-Pad3_ /Sheet632C252D/VDD PMOS_OR1 l=1u w=2u
M20 Net-_M19-Pad1_ Net-_M11-Pad1_ Net-_M16-Pad3_ 0 NMOS_OR1 l=1u w=2u
M19 Net-_M19-Pad1_ Net-_M11-Pad1_ Net-_M15-Pad3_ /Sheet632C252D/VDD PMOS_OR1 l=1u w=2u
M17 Net-_M15-Pad3_ Net-_M15-Pad1_ /Sheet632C252D/VDD /Sheet632C252D/VDD PMOS_OR1 l=1u w=2u
M18 Net-_M16-Pad3_ Net-_M15-Pad1_ 0 0 NMOS_OR1 l=1u w=2u
M22 /Sheet632C252D/VO Net-_M19-Pad1_ 0 0 NMOS_OR1 l=1u w=2u
M21 /Sheet632C252D/VO Net-_M19-Pad1_ /Sheet632C252D/VDD /Sheet632C252D/VDD PMOS_OR1 l=1u w=17u
.tran 10ns 10ns
.end
