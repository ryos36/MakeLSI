.title KiCad schematic
M1 Net-_M1-Pad1_ Net-_M1-Pad1_ /VDD /VDD PMOS_OR1 l=1u w=2u
M5 Net-_M3-Pad3_ Net-_M1-Pad1_ /VSS /VSS NMOS_OR1 l=1u w=2u
M2 Net-_M1-Pad1_ Net-_M1-Pad1_ /VSS /VSS NMOS_OR1 l=1u w=2u
M6 /Judgement-Stage/Vin1 /Judgement-Stage/Vin1 /VDD /VDD PMOS_OR1 l=1u w=2u
M3 /Judgement-Stage/Vin2 NC_01 Net-_M3-Pad3_ /VSS NMOS_OR1 l=1u w=2u
M7 /Judgement-Stage/Vin1 NC_02 Net-_M3-Pad3_ /VSS NMOS_OR1 l=1u w=2u
M4 /Judgement-Stage/Vin2 /Judgement-Stage/Vin2 /VDD /VDD PMOS_OR1 l=1u w=2u
M14 /Output-Stage/Vin1 /Output-Stage/Vin1 Net-_M10-Pad1_ /VSS NMOS_OR1 l=1u w=2u
M13 /Output-Stage/Vin1 /Output-Stage/Vin2 Net-_M10-Pad1_ /VSS NMOS_OR1 l=1u w=2u
M10 Net-_M10-Pad1_ Net-_M10-Pad1_ /VSS /VSS NMOS_OR1 l=1u w=2u
M11 /Output-Stage/Vin2 /Output-Stage/Vin1 Net-_M10-Pad1_ /VSS NMOS_OR1 l=1u w=2u
M12 /Output-Stage/Vin1 /Judgement-Stage/Vin1 /VDD /VDD PMOS_OR1 l=1u w=2u
M9 /Output-Stage/Vin2 /Output-Stage/Vin2 Net-_M10-Pad1_ /VSS NMOS_OR1 l=1u w=2u
M8 /Output-Stage/Vin2 /Judgement-Stage/Vin2 /VDD /VDD PMOS_OR1 l=1u w=2u
M20 Net-_M19-Pad1_ /Output-Stage/Vin2 Net-_M16-Pad3_ /VSS NMOS_OR1 l=1u w=2u
M19 Net-_M19-Pad1_ /Output-Stage/Vin2 Net-_M15-Pad3_ /VDD PMOS_OR1 l=1u w=2u
M18 Net-_M16-Pad3_ Net-_M15-Pad1_ /VSS /VSS NMOS_OR1 l=1u w=2u
M16 Net-_M15-Pad1_ /Output-Stage/Vin1 Net-_M16-Pad3_ /VSS NMOS_OR1 l=1u w=2u
M17 Net-_M15-Pad3_ Net-_M15-Pad1_ /VDD /VDD PMOS_OR1 l=1u w=2u
M15 Net-_M15-Pad1_ /Output-Stage/Vin1 Net-_M15-Pad3_ /VDD PMOS_OR1 l=1u w=2u
M22 /Vout Net-_M19-Pad1_ /VSS /VSS NMOS_OR1 l=1u w=2u
M21 /Vout Net-_M19-Pad1_ /VDD /VDD PMOS_OR1 l=1u w=6u
.end
